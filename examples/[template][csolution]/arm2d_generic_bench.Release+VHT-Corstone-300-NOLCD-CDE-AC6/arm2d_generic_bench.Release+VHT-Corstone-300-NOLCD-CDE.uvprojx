# Keil uVision project arm2d_generic_bench.Release+VHT-Corstone-300-NOLCD-CDE.uvprojx, settings and files
target Release+VHT-Corstone-300-NOLCD-CDE (6210000::V6.21::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.4.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) XRAM(0x00000000,0x00080000) XRAM2(0x01000000,0x00100000) XRAM3(0x20000000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: arm2d_generic_bench.axf
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=6
  c define: __ARM_2D_HAS_ANTI_ALIAS_TRANSFORM__ __ARM_2D_NOLCD __ARM_2D_CFG_BENCHMARK_EXIT_WHEN_FINISH__ __ARM_2D_CFG_ENABLE_LOG__=1
  c misc: -ffast-math -Wno-macro-redefined -Wno-pragma-pack -Wno-parentheses-equality -Wno-license-management -mcpu=cortex-m55+cdecp0 -ffast-math -Wno-macro-redefined -Wno-pragma-pack -Wno-parentheses-equality -Wno-license-management -mcpu=cortex-m55+cdecp0
  c include: ../../Acceleration/Arm/ACI
  asm define: as above
  asm include: ../../Acceleration/Arm/ACI
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT7: RAM 0x1000000 size 0x100000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ../linker/sse300_mps3/ac6_sse300_mps3_s.sct
  link misc: --entry=Reset_Handler --info summarysizes --diag_suppress=L6314W
  group App
    ../: main.c
  group platform_mps3
    ../../examples/common/platform/mps3/: GLCD_V2M-MPS3_AN540.c platform_mps3.c
  group arm2d_rgb565_cde
    ../../Acceleration/Arm/ACI/: arm_2d_rgb565_aci_lib.c
software components: Acceleration:Arm-2D Extras:Benchmark-Generic 1.4.3, Acceleration:Arm-2D Extras:Controls 1.5.8, Acceleration:Arm-2D Extras:LCD ASCII Printf 2.2.1, Acceleration:Arm-2D Helper:Display Adapter 2.1.0, Acceleration:Arm-2D Helper:PFB 1.9.0, Acceleration:Arm-2D:Alpha-Blending 1.1.5, Acceleration:Arm-2D:Core 1.1.5, Acceleration:Arm-2D:Transform 1.1.6, CMSIS-Compiler:CORE 1.0.0, CMSIS-Compiler:STDOUT:ITM 1.0.0, CMSIS:CORE 5.7.0, CMSIS:DSP 1.15.0, Device:Definition 2.0.0, Device:Native Driver:SysCounter 1.1.0, Device:Native Driver:SysTimer 1.1.0, Device:Native Driver:Timeout 1.0.0, Device:Startup 2.0.0, Utilities:perf_counter:Core 2.2.3
