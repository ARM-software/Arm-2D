# Keil uVision project template.uvprojx, settings and files
target V2M-MPS2-CM4 (6230000::V6.23::.\ArmCompilerforEmbedded6.24)
  device: CMSDK_CM4_FP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.1
  cpu: IROM(0x00000000,0x400000) IRAM(0x20000000,0x400000) CPUTYPE("Cortex-M4") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: template
  c flags: oTime=1 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: GLCD_MIRROR_X=1,GLCD_MIRROR_Y=0
  c misc: -Omax
  c include: ..\..\..\common\platform;..\..\;..\..\..\common\platform\mps2;..\..\..\common\scenes\meter;..\..\..\common\scenes\fitness;..\..\..\common\scenes\watch;..\..\..\demos;..\..\..\common\scenes\alarm_clock;..\..\..\common\scenes\histogram;..\..\..\common\scenes\fan;..\..\..\common\scenes\bubble_charging;.;..\..\..\common\scenes\knob;..\..\..\common\scenes\animate_background;..\..\..\common\opcodes
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\mps2.sct
  link misc: --entry=Reset_Handler 
--diag_suppress=6314,6329
  group Source Files
    ../../: main.c app_cfg.h
    ../../../common/scenes/alarm_clock/: arm_2d_scene_alarm_clock.c arm_2d_scene_alarm_clock.h
    ../../../common/scenes/histogram/: arm_2d_scene_histogram.c arm_2d_scene_histogram.h
    ../../../common/scenes/meter/: arm_2d_scene_meter.c arm_2d_scene_meter.h
    ../../../common/scenes/fitness/: arm_2d_scene_fitness.c arm_2d_scene_fitness.h
    ../../../common/scenes/watch/: arm_2d_scene_watch.c arm_2d_scene_watch.h
    ../../../common/scenes/fan/: arm_2d_scene_fan.c arm_2d_scene_fan.h
    ../../../common/scenes/bubble_charging/: arm_2d_scene_bubble_charging.c arm_2d_scene_bubble_charging.h
    ./: arm_2d_scene_animate_background.c
    ../../../common/scenes/knob/: arm_2d_scene_knob.c arm_2d_scene_knob.h
    ../../../common/scenes/animate_background/: arm_2d_scene_animate_background.h arm_2d_scene_animate_background_vres.c
    ../../../common/asset/: wedge_pattern.c radial_line_cover.c radial_line_pattern.c knob_circle_quater.c MeterPanel.c
  group platform
    ../../../common/platform/: app_platform.c Board_GLCD.h platform.h
  group bsp_mps2
    ../../../common/platform/mps2/: GLCD_V2M-MPS2.c platform_mps2.c stdout_USART.c GLCD_Config.h
  group bsp_mps3
    ../../../common/platform/mps3/: GLCD_V2M-MPS3_AN540.c platform_mps3.c stdout_USART.c GLCD_Config.h
  group bsp_stm32f746g-discovery
    ../../../common/platform/stm32f746g-discovery/: GLCD_746G_Discovery.c platform_stm32f746g_discovery.c GLCD_Config.h
  group ACI
    ../../../../Acceleration/Arm/ACI/: arm_2d_rgb565_aci_lib.c arm_2d_rgb565_aci_lib.h arm_2d_user_aci.h
target FastModel (6230000::V6.23::.\ArmCompilerforEmbedded6.24)
  device: CMSDK_CM4_FP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.1
  cpu: as above
  output: template
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: GLCD_MIRROR_X=1,GLCD_MIRROR_Y=0,ITERATION_CNT=10
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\mps2.sct
  link misc: --entry=Reset_Handler --diag_suppress=6314,6329
target V2M-MPS2-CM33 (6230000::V6.23::.\ArmCompilerforEmbedded6.24)
  device: IOTKit_CM33_FP ARM
  pack: Keil.V2M-MPS2_IOTKit_BSP.1.5.1
  cpu: IRAM(0x38000000,0x00200000) IRAM2(0x28200000,0x00200000) IROM(0x10000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: template
  c flags: oTime=1 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: GLCD_MIRROR_X=1,GLCD_MIRROR_Y=0
  c misc: -Omax
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x38000000 size 0x200000
  memory RVCT10: RAM 0x28200000 size 0x200000
  scatter file: .\MPS2_CM33.sct
  link misc: --entry=Reset_Handler
--diag_suppress=6314,6329,6848
target V2M-MPS3-CM55_Deprecated (6230000::V6.23::.\ArmCompilerforEmbedded6.24)
  device: ARMCM55 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: template
  c flags: oTime=1 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=2
  c define: LCD_MIRROR_X=1,GLCD_MIRROR_Y=0
  c misc: -Omax
  c include: ..\..\..\common\platform;..\..\;..\..\..\common\platform\mps3\v2m_mps3;..\..\..\common\platform\mps3;..\..\..\common\scenes\meter;..\..\..\common\scenes\fitness;..\..\..\common\scenes\watch;..\..\..\demos;..\..\..\common\scenes\alarm_clock;..\..\..\common\scenes\fan;..\..\..\common\scenes\bubble_charging;.;..\..\..\common\scenes\knob;..\..\..\common\scenes\animate_background;..\..\..\common\opcodes;..\..\..\common\scenes\histogram
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\MPS3_CM55_DTCM.sct
  link misc: --entry=Reset_Handler
--diag_suppress=6314,6329,6848
target V2M-MPS2-CM0+ (6230000::V6.23::.\ArmCompilerforEmbedded6.24)
  device: CMSDK_CM0plus ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.1
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: template
  c flags: oTime=1 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: GLCD_MIRROR_X=1,GLCD_MIRROR_Y=0
  c misc: -Omax
  c include: ..\..\..\common\platform;..\..\;..\..\..\common\platform\mps2;..\..\..\common\scenes\meter;..\..\..\common\scenes\fitness;..\..\..\common\scenes\watch;..\..\..\demos;..\..\..\common\scenes\alarm_clock;..\..\..\common\scenes\histogram;..\..\..\common\scenes\fan;..\..\..\common\scenes\bubble_charging;..\mdk;..\..\..\common\scenes\knob;..\..\..\common\scenes\animate_background;..\..\..\common\opcodes
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\mps2.sct
  link misc: --entry=Reset_Handler 
--diag_suppress=6314,6329
target V2M-MPS2-CM7 (6230000::V6.23::.\ArmCompilerforEmbedded6.24)
  device: CMSDK_CM7_DP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.1
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: template
  c flags: oTime=1 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=2
  c define: GLCD_MIRROR_X=1,GLCD_MIRROR_Y=0
  c misc: -Omax -Wno-nonportable-include-path
  c include: as above
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\mps2.sct
  link misc: --entry=Reset_Handler 
--diag_suppress=6314,6329
target STM32F746G-Discovery (6240000::V6.24::.\ArmCompilerforEmbedded6.24)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.2
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=5 oTime=1 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: __GLCD_CFG_SCEEN_WIDTH__=480,__GLCD_CFG_SCEEN_HEIGHT__=272,__DISP0_CFG_SCEEN_WIDTH__=480,__DISP0_CFG_SCEEN_HEIGHT__=272,__DISP0_CFG_PFB_BLOCK_WIDTH__=480,__DISP0_CFG_PFB_BLOCK_HEIGHT__=28,ARM_2D_SCENE_METER_USE_JPG,ARM_2D_SCENE_HISTOGRAM_USE_JPG
  c misc: -Wno-nonportable-include-path
  c include: ..\..\;..\..\..\common\platform;..\..\..\common\platform\stm32f746g-discovery;..\..\..\common\scenes\meter;..\..\..\common\scenes\fitness;..\..\..\common\scenes\watch;..\..\..\demos;..\..\..\common\scenes\alarm_clock;..\..\..\common\scenes\histogram;..\..\..\common\scenes\fan;..\..\..\common\scenes\bubble_charging;.;..\..\..\common\scenes\knob;..\..\..\common\scenes\animate_background;..\..\..\common\opcodes
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x3f800
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\stm32f746g.sct
  link misc: --entry=Reset_Handler 
--diag_suppress=6314,6329
target AN547-AN556 (6240000::V6.24::.\ArmCompilerforEmbedded6.24)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.5.0
  cpu: IRAM(0x00000000,0x00080000) IRAM2(0x01000000,0x00200000) XRAM(0x20000000,0x00020000) XRAM2(0x20020000,0x00020000) XRAM3(0x20040000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: template
  c flags: Optim=6 oTime=1 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: LCD_MIRROR_X=1,GLCD_MIRROR_Y=0,__USE_AN547__
  c misc: -Wno-padded
  c include: ..\..\..\common\platform;..\..\;..\..\..\common\platform\mps3\v2m_mps3;..\..\..\common\platform\mps3;..\..\..\common\scenes\meter;..\..\..\common\scenes\fitness;..\..\..\common\scenes\watch;..\..\..\demos;..\..\..\common\scenes\alarm_clock;..\..\..\common\scenes\histogram;..\..\..\common\scenes\fan;..\..\..\common\scenes\bubble_charging;.;..\..\..\common\scenes\knob;..\..\..\common\scenes\animate_background;..\..\..\common\opcodes
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: .\RTE\Device\SSE-300-MPS3\fvp_sse300_mps3_s.sct
  link misc: --entry=Reset_Handler
--diag_suppress=6314,6329,6848
target STM32F746G-Discovery-AC5 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.2
  cpu: as above
  output: template
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 wLevel=2
  c include: ..\..\..\common\platform;..\..\..\common\platform\stm32f746g-discovery;..\..\;..\..\..\common\scenes\meter;..\..\..\common\scenes\fitness;..\..\..\common\scenes\watch;..\..\..\demos;..\..\..\common\scenes\alarm_clock;..\..\..\common\scenes\histogram;..\..\..\common\scenes\fan;..\..\..\common\scenes\bubble_charging;.;..\..\..\common\scenes\knob;..\..\..\common\scenes\animate_background;..\..\..\common\opcodes
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x3f800
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\stm32f746g.sct
  link misc: --entry=Reset_Handler 
--diag_suppress=6314,6329
target V2M-MPS3-CM85 (6240000::V6.24::.\ArmCompilerforEmbedded6.24)
  device: ARMCM85 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x30000000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x10000000,0x00200000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ESEL ELITTLE
  output: template
  c flags: Optim=8 oTime=1 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=2
  c define: LCD_MIRROR_X=1,GLCD_MIRROR_Y=0
  c misc: -Wno-invalid-utf8
  c include: ..\..\..\common\platform;..\..\;..\..\..\common\platform\mps3\v2m_mps3;..\..\..\common\platform\mps3;..\..\..\common\scenes\meter;..\..\..\common\scenes\fitness;..\..\..\common\scenes\watch;..\..\..\demos;..\..\..\common\scenes\alarm_clock;..\..\..\common\scenes\histogram;..\..\..\common\scenes\fan;..\..\..\common\scenes\bubble_charging;..\..\..\common\scenes\knob;..\..\..\common\scenes\animate_background;..\..\..\common\opcodes
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\MPS3_CM55_DTCM.sct
  link misc: --entry=Reset_Handler
--diag_suppress=6314,6329,6848
target AN552_Cortex-M55 (6240000::V6.24::.\ArmCompilerforEmbedded6.24)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.5.0
  cpu: as above
  output: template
  c flags: as above
  c define: LCD_MIRROR_X=1,GLCD_MIRROR_Y=0,__USE_AN547__
  c misc: -Wno-padded -mcpu=cortex-m55+cdecp0
  c include: ..\..\..\common\platform;..\..\;..\..\..\common\platform\mps3\v2m_mps3;..\..\..\common\platform\mps3;..\..\..\common\scenes\meter;..\..\..\common\scenes\fitness;..\..\..\common\scenes\watch;..\..\..\demos;..\..\..\common\scenes\alarm_clock;..\..\..\common\scenes\histogram;..\..\..\common\scenes\fan;..\..\..\..\Acceleration\Arm\ACI;..\..\..\common\scenes\bubble_charging;..\..\..\common\scenes\knob;..\..\..\common\scenes\animate_background;..\..\..\common\opcodes
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: .\RTE\Device\SSE-300-MPS3\fvp_sse300_mps3_s.sct
  link misc: --entry=Reset_Handler
--diag_suppress=6314,6329,6848
software components: Acceleration:Arm-2D Demos:Atom 1.2.0, Acceleration:Arm-2D Demos:AudioMark 1.0.3, Acceleration:Arm-2D Demos:Basics 1.4.0, Acceleration:Arm-2D Demos:Compass 1.2.1, Acceleration:Arm-2D Demos:ConsoleWindow 1.1.0, Acceleration:Arm-2D Demos:Decoding JPG with TJpgDec 1.0.0, Acceleration:Arm-2D Demos:Filters 1.2.1, Acceleration:Arm-2D Demos:Gas Gauge 1.1.1, Acceleration:Arm-2D Demos:Hollow Out List 1.2.2, Acceleration:Arm-2D Demos:Listview 1.0.2, Acceleration:Arm-2D Demos:Matrix 1.0.0, Acceleration:Arm-2D Demos:Menu 1.1.0, Acceleration:Arm-2D Demos:Monochrome 1.6.0, Acceleration:Arm-2D Demos:Panel 1.2.1, Acceleration:Arm-2D Demos:Progress and Status 1.1.2, Acceleration:Arm-2D Demos:Ruler 1.2.0, Acceleration:Arm-2D Demos:Showing Animation with TJpgDec 1.0.1, Acceleration:Arm-2D Demos:Text Reader 0.9.1, Acceleration:Arm-2D Demos:Transform 2.1.0, Acceleration:Arm-2D Demos:User Defined OPCODE 2.1.1, Acceleration:Arm-2D Demos:Virtual Resources 1.2.0, Acceleration:Arm-2D Demos:Watch Face 01 1.2.0, Acceleration:Arm-2D Extras:Controls 2.5.0, Acceleration:Arm-2D Extras:LCD ASCII Printf 2.11.0, Acceleration:Arm-2D Extras:Loaders 2.1.1, Acceleration:Arm-2D Helper:Display Adapter 3.3.8, Acceleration:Arm-2D Helper:PFB 2.6.0, Acceleration:Arm-2D:Alpha-Blending 1.2.2-dev, Acceleration:Arm-2D:Core 1.2.2-dev, Acceleration:Arm-2D:Filter 1.2.2-dev, Acceleration:Arm-2D:Transform 1.2.2-dev, CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2, Device:Definition 2.0.0, Device:Native Driver:SysCounter 1.1.0, Device:Native Driver:SysTimer 1.1.0, Device:Native Driver:Timeout 1.0.0, Device:Startup 2.0.0, Device:Startup 2.2.0, Device:Startup 2.2.0, Utilities:perf_counter:Core 2.4.0, Board Support:Drivers:SDRAM 1.1.1, CMSIS Driver:USART 1.0.0, CMSIS Driver:USART 1.0.3, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0, Device:STM32Cube Framework:Classic 1.3.0, Device:STM32Cube HAL:Common 1.3.0, Device:STM32Cube HAL:Cortex 1.3.0, Device:STM32Cube HAL:DMA 1.3.0, Device:STM32Cube HAL:GPIO 1.3.0, Device:STM32Cube HAL:LTDC 1.3.0, Device:STM32Cube HAL:PWR 1.3.0, Device:STM32Cube HAL:RCC 1.3.0, Device:STM32Cube HAL:SDRAM 1.3.0, Device:STM32Cube LL:Common 1.3.0, Device:STM32Cube LL:PWR 1.3.0, Device:STM32Cube LL:RCC 1.3.0, Device:STM32Cube LL:UTILS 1.3.0, Device:Startup 1.2.0, Device:Startup 1.1.0, Device:Startup 1.1.0, Device:Startup 1.1.0, Device:Startup 1.2.5
