# Keil uVision project gcc_template.uvprojx, settings and files
target STM32F746G-Discovery-GCC (6160000::V6.16::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.2
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: gcc_template
  AfterMake: arm-none-eabi-size.exe ./Objects/gcc_template.elf
  group Application
    ../../: app_cfg.h main.c
    ../../../common/scenes/fitness/: arm_2d_scene_fitness.c arm_2d_scene_fitness.h
    ../../../common/scenes/meter/: arm_2d_scene_meter.c arm_2d_scene_meter.h
    ../../../common/scenes/alarm_clock/: arm_2d_scene_alarm_clock.c arm_2d_scene_alarm_clock.h
    ../../../common/scenes/bubble_charging/: arm_2d_scene_bubble_charging.c arm_2d_scene_bubble_charging.h
    ../../../common/scenes/fan/: arm_2d_scene_fan.c arm_2d_scene_fan.h
    ../../../common/scenes/histogram/: arm_2d_scene_histogram.c arm_2d_scene_histogram.h
    ../../../common/scenes/watch/: arm_2d_scene_watch.c arm_2d_scene_watch.h
    ../../../common/scenes/animate_background/: arm_2d_scene_animate_background.c arm_2d_scene_animate_background.h
    ../../../common/scenes/knob/: arm_2d_scene_knob.c arm_2d_scene_knob.h
    ../../../common/asset/: arm_2d_asset_knob_circle_quater.c arm_2d_asset_radial_line_cover.c arm_2d_asset_wedge_pattern.c
  group Platform
    ./RTE/Device/STM32F746NGHx/: system_stm32f7xx.c
    ../../../common/platform/: app_platform.c platform.h
    ../../../common/platform/stm32f746g-discovery/: GLCD_746G_Discovery.c platform_stm32f746g_discovery.c startup_ARMCM7.c
software components: Acceleration:Arm-2D Demos:Atom 1.2.1, Acceleration:Arm-2D Demos:AudioMark 1.0.5, Acceleration:Arm-2D Demos:Balls 1.0.0, Acceleration:Arm-2D Demos:Basics 2.0.0, Acceleration:Arm-2D Demos:Blink 2.4.2, Acceleration:Arm-2D Demos:Compass 1.3.1, Acceleration:Arm-2D Demos:ConsoleWindow 1.1.1, Acceleration:Arm-2D Demos:Decoding JPG with TJpgDec 1.1.0, Acceleration:Arm-2D Demos:Filters 1.2.2, Acceleration:Arm-2D Demos:Flight Attitude Instrument 1.5.0, Acceleration:Arm-2D Demos:Gas Gauge 1.2.1, Acceleration:Arm-2D Demos:Hollow Out List 1.3.0, Acceleration:Arm-2D Demos:IIR Blur 1.0.1, Acceleration:Arm-2D Demos:Listview 1.0.3, Acceleration:Arm-2D Demos:Loading Lossless image with QOI 1.3.1, Acceleration:Arm-2D Demos:Mask Generator 1.2.0, Acceleration:Arm-2D Demos:Matrix 2.0.1, Acceleration:Arm-2D Demos:Menu 1.1.1, Acceleration:Arm-2D Demos:Monochrome 1.6.2, Acceleration:Arm-2D Demos:Music Player 3.0.0, Acceleration:Arm-2D Demos:Panel 1.3.0, Acceleration:Arm-2D Demos:Progress and Status 2.5.1, Acceleration:Arm-2D Demos:QRCode 1.0.0, Acceleration:Arm-2D Demos:Radars 4.3.0, Acceleration:Arm-2D Demos:Ring Indicator 1.1.2, Acceleration:Arm-2D Demos:Ruler 1.4.0, Acceleration:Arm-2D Demos:Shaped Panel 1.0.0, Acceleration:Arm-2D Demos:Showing Animation with TJpgDec 2.3.0, Acceleration:Arm-2D Demos:Space Badge 2.0.0, Acceleration:Arm-2D Demos:Text Reader 2.0.0, Acceleration:Arm-2D Demos:Transform 2.1.3, Acceleration:Arm-2D Demos:User Defined OPCODE 3.0.0, Acceleration:Arm-2D Demos:Virtual Resources 2.0.0, Acceleration:Arm-2D Demos:Watch Face 01 1.2.2, Acceleration:Arm-2D Demos:Waveform 2.1.0, Acceleration:Arm-2D Extras:Controls 2.16.2, Acceleration:Arm-2D Extras:LCD ASCII Printf 3.0.2, Acceleration:Arm-2D Extras:Loaders 5.6.11, Acceleration:Arm-2D Helper:Display Adapter 4.4.4, Acceleration:Arm-2D Helper:PFB 3.2.9, Acceleration:Arm-2D Render Test:Font Rendering 0.9.0, Acceleration:Arm-2D Render Test:Tile Paving 2.1.0, Acceleration:Arm-2D:Alpha-Blending 1.2.6, Acceleration:Arm-2D:Core 1.2.6, Acceleration:Arm-2D:Filter 1.2.6, Acceleration:Arm-2D:Transform 1.2.6, CMSIS:CORE 6.1.1, CMSIS:DSP 1.16.2, Utilities:perf_counter:Core 2.5.5-dev, Board Support:Drivers:SDRAM 1.1.1, Device:STM32Cube Framework:Classic 1.3.0, Device:STM32Cube HAL:Common 1.3.0, Device:STM32Cube HAL:Cortex 1.3.0, Device:STM32Cube HAL:DMA 1.3.0, Device:STM32Cube HAL:GPIO 1.3.0, Device:STM32Cube HAL:LTDC 1.3.0, Device:STM32Cube HAL:PWR 1.3.0, Device:STM32Cube HAL:RCC 1.3.0, Device:STM32Cube HAL:SDRAM 1.3.0, Device:STM32Cube HAL:USART 1.3.0, Device:STM32Cube LL:Common 1.3.0, Device:STM32Cube LL:PWR 1.3.0, Device:STM32Cube LL:RCC 1.3.0, Device:STM32Cube LL:USART 1.3.0, Device:STM32Cube LL:UTILS 1.3.0, Device:Startup 1.2.5
