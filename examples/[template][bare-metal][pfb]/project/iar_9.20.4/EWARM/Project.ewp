# IAR project Project.ewp, settings and files
configuration STM32746G_DISCOVERY (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F756xx; USE_STM32746G_DISCOVERY; __DISP0_CFG_SCEEN_WIDTH__=480; __DISP0_CFG_SCEEN_HEIGHT__=272; __DISP0_CFG_PFB_BLOCK_WIDTH__=120; __DISP0_CFG_PFB_BLOCK_HEIGHT__=120; __ARM_2D_HAS_ANTI_ALIAS_TRANSFORM__=1
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/CMSIS/Device/ST/STM32F7xx/Include; ../Drivers/STM32F7xx_HAL_Driver/Inc; ../Drivers/BSP/STM32746G-Discovery; ../Drivers/BSP/Components/Common; ../Utilities/Log; ../Utilities/Fonts; ../Utilities/CPU; ..\..\..\..\..\Helper\Include; ..\..\..\..\..\Library\Include; ..\..\..\..\..\Library\Include\template; ..\..\..\..\common\platform\stm32f746g-discovery; ..\..\..\..\common\platform; ..\..\..; ..\..\..\..\common\platform\lib; ..\..\mdk\RTE\_STM32F746G-Discovery; ..\..\mdk\RTE\Acceleration; ..\..\..\..\common\controls; ..\..\..\..\common\asset
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32746G_DISCOVERY.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\common\platform\lib\libperf_counter_gcc.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../: app_cfg.h main.c
    ../../mdk/RTE/Acceleration/: arm_2d_cfg.h arm_2d_disp_adapter_0.c arm_2d_disp_adapter_0.h arm_2d_scene_0.c arm_2d_scene_0.h arm_2d_scene_1.c arm_2d_scene_1.h arm_2d_scene_2.c arm_2d_scene_2.h arm_2d_scene_3.c arm_2d_scene_3.h
  group Arm-2D/common/Asset
    ../../../../common/asset/: arrow.c blue_slashes.c circle_mask.c clockface.c cmsis_logo.c DigitsFont.c gear_01.c gear_02.c green28_28.c GreenCircle.c helium.c ListCover.c pointer_sec.c QuaterArc.c small_icon_sun.c software.c SpinWheel.c star.c wave.c white_dot.c
  group Arm-2D/common/controls
    ../../../../common/controls/: __common.h arm_extra_controls.h arm_extra_lcd_printf.h busy_wheel.c busy_wheel.h controls.c GLCD_Fonts.c lcd_printf.c list_view.c list_view.h number_list.c number_list.h progress_bar_drill.c progress_bar_drill.h progress_bar_flowing.c progress_bar_flowing.h progress_bar_simple.c progress_bar_simple.h progress_wheel.c progress_wheel.h shape_round_corner_box.c shape_round_corner_box.h spinning_wheel_transform.c spinning_wheel_transform.h
  group Arm-2D/Helper
    ../../../../../Helper/Source/: arm_2d_helper.c arm_2d_helper_list.c arm_2d_helper_pfb.c arm_2d_helper_scene.c
    ../../../../../Helper/Include/: arm_2d_helper.h arm_2d_helper_pfb.h
  group Arm-2D/Library/Include
    ../../../../../Library/Include/: __arm_2d_paving.h arm_2d.h arm_2d_alpha_blending.h arm_2d_conversion.h arm_2d_draw.h arm_2d_features.h arm_2d_op.h arm_2d_tile.h arm_2d_transform.h arm_2d_types.h arm_2d_utils.h
  group Arm-2D/Library/Source
    ../../../../../Library/Source/: arm_2d.c arm_2d_alpha_blending.c arm_2d_async.c arm_2d_conversion.c arm_2d_draw.c arm_2d_helium.c arm_2d_transform.c
  group Platform
    ../../../../common/platform/: app_platform.c
    ../../../../common/platform/lib/: perf_counter.c
  group STM32F746_Discovery/Doc
    ../: readme.txt
  group STM32F746_Discovery/Drivers/BSP/STM32746G-Discovery
    ../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c
  group STM32F746_Discovery/Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group STM32F746_Discovery/Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c
  group STM32F746_Discovery/User
    ../../../platform/stm32f746g-discovery/: GLCD_746G_Discovery.c
    ../../../../common/platform/stm32f746g-discovery/: startup_ARMCM7.c
    ../Src/: stm32f746_discovery_platform.c stm32f7xx_hal_msp.c stm32f7xx_it.c
